# Keil uVision project project.uvprojx, settings and files
target Flash (6150000::V6.15::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\uC-CPU\ARM-Cortex-M\ARMv7-M\RealView;..\..\uCOS-III\uC-LIB;..\..\uCOS-III\uCOS-III\Source;..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\RealView;..\..\emWin\Include;..\..\emWin\Config;..\..\emWin\emWinTask;..\..\emWin\emWinDemo;..\..\emWin\JPEGConf;..\..\User\fonts;..\..\Libraries\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ../../User/: main.c includes.h lib_cfg.h app_cfg.h cpu_cfg.h os_cfg.h os_cfg_app.h os_app_hooks.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h bsp_clk.c bsp_os.c bsp_cpu.c stm32h7xx_it.c bsp_int_armv7m.c
    ../../User/bsp/src/: bsp_led.c bsp_key.c bsp_timer.c bsp_beep.c bsp_fmc_io.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_i2c_gpio.c bsp_fmc_sdram.c bsp_i2c_eeprom_24xx.c bsp_cpu_rtc.c AD1292.c bsp_spi_bus.c AD7124.c AD7124v1.c
    ../../User/: stm32h7xx_hal_timebase_tim.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_mdma.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group uC/CPU
    ../../uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../../uCOS-III/uC-CPU/: cpu_core.c cpu_cache.h cpu_core.h cpu_def.h
  group uC/LIB
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-III Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/RealView/: os_cpu.h os_cpu_a.asm os_cpu_isr.asm
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
  group GUI/Driver
    ../../User/bsp/src/: bsp_tft_h7.c bsp_tft_lcd.c bsp_ts_touch.c bsp_ts_ft5x06.c bsp_ts_gt911.c bsp_ts_gt811.c bsp_ts_stmpe811.c
  group GUI/GUI_OS
    ../../emWin/GUI_X/: GUI_X_uCOS-III.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
  group GUI/Demo
    ../../emWin/emWinTaskV2/: App_SysFunction.c Logo_armfly.c MainTask.c Yahei.c
    ../../emWin/emWinTask/: FontSpecialChar.c
  group GUI/JPEG
    ../../emWin/JPEGConf/: JPEGConf.c JPEGConf.h decode_dma.c decode_dma.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin_CM7_OS_wc16_ot_ARGB.a
  group Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c fonts.h hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group CMSIS/DSP
    ../../Libraries/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
