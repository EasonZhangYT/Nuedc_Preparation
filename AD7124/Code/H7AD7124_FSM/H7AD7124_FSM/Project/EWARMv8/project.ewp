# IAR project project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include; ..\..\Libraries\STM32H7xx_HAL_Driver\Inc; ..\..\User\bsp\inc; ..\..\User; ..\..\User\bsp; ..\..\uCOS-III\uC-CPU; ..\..\uCOS-III\uC-CPU\ARM-Cortex-M\ARMv7-M\RealView; ..\..\uCOS-III\uC-LIB; ..\..\uCOS-III\uCOS-III\Source; ..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\RealView; ..\..\emWin\Include; ..\..\emWin\Config; ..\..\emWin\emWinTask; ..\..\emWin\emWinDemo; ..\..\emWin\JPEGConf; ..\..\User\fonts
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/bsp/: bsp.c bsp.h bsp_clk.c bsp_cpu.c bsp_int_armv7m.c bsp_os.c stm32h7xx_it.c
    ../../User/bsp/src/: bsp_beep.c bsp_fmc_io.c bsp_fmc_sdram.c bsp_i2c_eeprom_24xx.c bsp_i2c_gpio.c bsp_key.c bsp_led.c bsp_tim_pwm.c bsp_timer.c bsp_uart_fifo.c
    ../../User/: stm32h7xx_hal_timebase_tim.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group EWARMv8
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h743xx.s
  group Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c fonts.h hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
  group GUI/Demo
    ../../emWin/emWinTask/: MainTask.c MainTask.h TestJpeg.c
  group GUI/Driver
    ../../User/bsp/src/: bsp_tft_h7.c bsp_tft_lcd.c bsp_ts_ft5x06.c bsp_ts_gt811.c bsp_ts_gt911.c bsp_ts_stmpe811.c bsp_ts_touch.c
  group GUI/GUI_OS
    ../../emWin/GUI_X/: GUI_X_uCOS-III.c
  group GUI/JPEG
    ../../emWin/JPEGConf/: decode_dma.c decode_dma.h JPEGConf.c JPEGConf.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin_CM7_OS_wc32_ot_ARGB.a
  group HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_gpio.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
    ../../User/bsp/: stm32h7xx_hal_conf.h
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerIAR/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group uC/CPU
    ../../uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/IAR/: cpu.h cpu_a.asm
    ../../uCOS-III/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../uCOS-III/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-III Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu.h os_cpu_a.asm os_cpu_isr.asm
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
  group uC/OS-III Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group User
    ../../User/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h main.c os_app_hooks.c os_cfg.h os_cfg_app.h
